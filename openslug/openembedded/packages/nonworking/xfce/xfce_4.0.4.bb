SRC_URI = ${SOURCEFORGE_MIRROR}/xfce/xfce-${PV}-src.tar.bz2
